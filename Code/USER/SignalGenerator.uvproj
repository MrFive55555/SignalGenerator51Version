# Keil uVision project SignalGenerator.uvproj, settings and files
target SignalGenerator (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: SignalGenerator +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER;..\HARDWARE\AT24C02;..\HARDWARE\MatrixKeyboard;..\HARDWARE\NixieTube;..\HARDWARE\PCF8591;..\HARDWARE\IIC
  link misc: REMOVEUNUSED
  group USER
    ./: main.c SignalGeneratorUI.c SignalGeneratorUI.h
  group HARDWARE
    ../HARDWARE/MatrixKeyboard/: matrixKeyboard.c matrixKeyboard.h
    ../HARDWARE/NixieTube/: nixieTube.c nixieTube.h
    ../HARDWARE/PCF8591/: pcf8591.c pcf8591.h
    ../HARDWARE/IIC/: IIC.c IIC.h
    ../HARDWARE/AT24C02/: at24c02.c at24c02.h IICForAT.h IICForAT.c
